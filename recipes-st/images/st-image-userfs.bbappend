PACKAGE_INSTALL = " \
    sd-card-system-upgrade \
    libiio \
    m4projects-stm32mp1-userfs \
    linux-examples-stm32mp1-userfs \
    ppp \
    usb-modeswitch \
    ppp-dialin \
    "
